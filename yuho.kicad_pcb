# Repository shin-waseda/yuho-kicad_file

## KiCad design yuho.kicad_pcb

Parts:
BAT1: Conn_01x02; PinSocket_2x01_P2.00mm_Vertical
C1: 22μ; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C2: 1.0μ; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3: 0.33μ; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4: 4.7μ; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5, C9, C11, C12, C16, C17, C18, C20, C21, C22, C23, C24, C27: 0.1μ; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6, C13, C14: 2.2μ; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7: 10n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8, C10, C15: 10μ; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C19: 1μ; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C25: 4.7μ; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C26: 100μ; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D1, D2, D3, D4: SFH4550; LED_D5.0mm_IRGrey
D5, D7, D8, D9, D10, D11, D12, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D6, D13: MBR130LSFT1G; D_SOD-123F
FAN1: 8520モータ; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J1: Conn_02x05_Odd_Even; PinSocket_2x05_P1.27mm_Vertical_SMD
J2, J4: Conn_02x04_Odd_Even; PinHeader_2x04_P1.27mm_Vertical
J3: 47219-2001; microSD_HC_Molex_47219-2001
J_L1: Conn_02x03_Odd_Even; PinSocket_2x03_P2.54mm_Vertical
J_R1: Conn_02x03_Odd_Even; PinSocket_2x03_P2.54mm_Vertical
LS1: SMT-0540-S-R; XDCR_SMT-0540-S-R
Q1, Q3, Q5, Q7, Q10: 2N7002K; SOT-23
Q2, Q4, Q6, Q8: ST-1KL3A; LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm_Clear
Q9: AO3407A; SOT-23
Q12: AO3400A; SOT-23
R1, R6, R9, R12, R20, R21, R22, R23, R24, R25, R26, R31, R32, R33, R34, R35, R36, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52: 560; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R4, R7, R10, R16, R17, R18, R19, R27, R28, R30, R37, R38, R39, R40, R42: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R5, R8, R11: 20; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13: 0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14: 33k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R15: 20k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R41: 33; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: 113989; Nidec_Copal_CAS-120A
SW2, SW3, SW4: SKRPACE010; SW_SKRPACE010_AAL
U1: STM32F405RGTx; LQFP-64_10x10mm_P0.5mm
U2: LD1117S25TR_SOT223; SOT-223-3_TabPin2
U3: SOT-89-5
U4: LGA-14_3x2.5mm_P0.5mm_LayoutBorder3x4y
U5: TB6612FNG; SSOP-24_5.3x8.2mm_P0.65mm
U6, U7: 74HC595D; SOIC127P600X175-16N

Connections:
595_LATCH: J2.7, J4.7, U1.23 (PA7), U6.12 (RCLK), U7.12 (RCLK)
595_SCLK: J2.5, J4.5, U1.41 (PA8), U6.11 (SRCLK), U7.11 (SRCLK)
595_SER: J2.3, J4.3, U1.50 (PA15), U6.14 (SER)
+3.3V: C4.1, C5.1, C6.1, C7.1, C9.1, C10.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, J1.7, J2.1, J3.4 (VDD), J4.1, Q2.1 (C), Q4.1 (C), Q6.1 (C), Q8.1 (C), R18.1, R26.1, R28.1, R37.1, R38.1, R39.1, R40.1, R42.1, SW4.1, U1.1 (VBAT), U1.13 (VDDA), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U3.4 (Vout), U4.5 (VDDIO), U4.8 (VDD), U5.20 (VCC), U6.16 (VCC), U7.16 (VCC)
+5V: C1.1, C3.1, D6.1 (K), J1.9, J_L1.4, J_R1.4, LS1.1, R3.1, R5.1, R8.1, R11.1, U2.2 (VO), U3.1 (CONTROL), U3.5 (Vin)
BOOT: J2.4, J4.4, R19.1, SW4.2, U1.60 (BOOT0)
BUZZER: Q10.1 (G), R17.1, U1.57 (TIM3_CH2)
CS: U1.20 (PA4), U4.12 (AP_CS)
ENC_L_A: J_L1.6, U1.58 (TIM4_CH1)
ENC_L_B: J_L1.5, U1.59 (TIM4_CH2)
ENC_R_A: J_R1.6, U1.37 (TIM8_CH1)
ENC_R_B: J_R1.5, U1.38 (TIM8_CH2)
FAN: Q12.1 (G), R27.1, U1.56 (TIM3_CH1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C10.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C27.1, D5.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), J1.1, J2.2, J3.6 (VSS), J3.9 (SHIELD), J4.2, J_L1.3, J_R1.3, Q1.2 (S), Q3.2 (S), Q5.2 (S), Q7.2 (S), R1.2, R2.2, R4.2, R6.2, R7.2, R9.2, R10.2, R12.2, R13.1, R15.1, R19.2, R30.1, SW1.3 (A), SW2.2, SW3.2, U1.12 (VSSA), U1.18 (VSS), U1.63 (VSS), U2.1 (GND), U3.2 (GND), U4.6 (GND), U4.7 (RESV), U4.9 (INT2/FSYNC)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
GND2: BAT1.1, C8.2, C11.2, C26.2, Q10.2 (S), Q12.2 (S), R13.2, R17.2, R27.2, U5.3 (PGND1), U5.4 (PGND1), U5.9 (PGND2), U5.10 (PGND2)
IR_FL: Q5.1 (G), R7.1, U1.4 (PC15)
IR_FR: Q7.1 (G), R10.1, U1.6 (PH1)
IR_L: Q3.1 (G), R4.1, U1.3 (PC14)
IR_R: Q1.1 (G), R2.1, U1.5 (PH0)
LED_1: R20.1, U1.9 (PC1)
LED_2: R21.1, U1.10 (PC2)
LED_3: R22.1, U1.11 (PC3)
LED_4: R23.1, U1.2 (PC13)
LED_5: R24.1, U1.44 (PA11)
LED_6: R25.1, U1.33 (PB12)
MISO: U1.35 (SPI2_MISO), U4.1 (AP_SDO)
MOSI: U1.36 (SPI2_MOSI), U4.14 (AP_SDA)
MOTOR_L_CCW: U1.24 (PC4), U5.22 (AIN2)
MOTOR_L_CW: U1.25 (PC5), U5.21 (AIN1)
MOTOR_L_OUT1: J_L1.2, U5.1 (AO1), U5.2 (AO1)
MOTOR_L_OUT2: J_L1.1, U5.5 (AO2), U5.6 (AO2)
MOTOR_L_PWM: U1.21 (TIM2_CH1), U5.23 (PWMA)
MOTOR_R_CCW: U1.29 (PB10), U5.16 (BIN2)
MOTOR_R_CW: U1.27 (PB1), U5.17 (BIN1)
MOTOR_R_OUT1: J_R1.2, U5.7 (BO2), U5.8 (BO2)
MOTOR_R_OUT2: J_R1.1, U5.11 (BO1), U5.12 (BO1)
MOTOR_R_PWM: U1.30 (TIM2_CH4), U5.15 (PWMB)
MOTOR_STBY: U1.26 (PB0), U5.19 (STBY)
NRST: J2.6, J4.6, SW3.1, U1.7 (NRST)
unnamed: BAT1.2, Q9.2 (S), R16.2
unnamed: D1.2 (A), R3.2
unnamed: D1.1 (K), Q3.3 (D)
unnamed: D2.2 (A), R5.2
unnamed: D2.1 (K), Q1.3 (D)
unnamed: D3.2 (A), R8.2
unnamed: D3.1 (K), Q5.3 (D)
unnamed: D4.2 (A), R11.2
unnamed: D4.1 (K), Q7.3 (D)
unnamed: D5.2 (A), R20.2
unnamed: D6.2 (A), LS1.2, Q10.3 (D)
unnamed: D7.2 (A), R21.2
unnamed: D8.2 (A), R22.2
unnamed: D9.2 (A), R23.2
unnamed: D10.2 (A), R24.2
unnamed: D11.2 (A), R25.2
unnamed: D12.2 (A), R26.2
unnamed: C12.2, D13.2 (A), FAN1.2 (-), Q12.3 (D)
unnamed: D14.2 (A), R31.2
unnamed: D15.2 (A), R32.2
unnamed: D16.2 (A), R33.2
unnamed: D17.2 (A), R34.2
unnamed: D18.2 (A), R35.2
unnamed: D19.2 (A), R36.2
unnamed: D20.2 (A), R43.2
unnamed: D21.2 (A), R44.2
unnamed: D22.2 (A), R45.2
unnamed: D23.2 (A), R46.2
unnamed: D24.2 (A), R47.2
unnamed: D25.2 (A), R48.2
unnamed: D26.2 (A), R49.2
unnamed: D27.2 (A), R50.2
unnamed: D28.2 (A), R51.2
unnamed: D29.2 (A), R52.2
unnamed: J3.5 (CLK), R41.2
unnamed: Q9.1 (G), R16.1, SW1.2 (B)
unnamed: R30.2, U1.28 (PB2)
unnamed: C13.1, U1.31 (VCAP_1)
unnamed: C14.1, U1.47 (VCAP_2)
unnamed: R46.1, U6.15 (QA)
unnamed: R45.1, U6.1 (QB)
unnamed: R44.1, U6.2 (QC)
unnamed: R43.1, U6.3 (QD)
unnamed: R36.1, U6.4 (QE)
unnamed: R35.1, U6.5 (QF)
unnamed: R34.1, U6.6 (QG)
unnamed: U6.9 (QH'), U7.14 (SER)
unnamed: R33.1, U6.7 (QH)
unnamed: R28.2, U6.10 (~SRCLR), U7.10 (~SRCLR)
unnamed: R52.1, U7.15 (QA)
unnamed: R51.1, U7.1 (QB)
unnamed: R50.1, U7.2 (QC)
unnamed: R49.1, U7.3 (QD)
unnamed: R48.1, U7.4 (QE)
unnamed: R47.1, U7.5 (QF)
unnamed: R32.1, U7.6 (QG)
unnamed: R31.1, U7.7 (QH)
PUSH_IN_1: J2.8, J4.8, R18.2, SW2.1, U1.22 (PA6)
SCLK: U1.34 (SPI2_SCK), U4.13 (AP_SCLK)
SD_CLK: R41.1, U1.53 (SDIO_CK)
SD_CMD: J3.3 (CMD), R39.2, U1.54 (SDIO_CMD)
SD_DAT0: J3.7 (DAT0), R37.2, U1.39 (SDIO_D0)
SD_DAT1: J3.8 (DAT1), R38.2, U1.40 (SDIO_D1)
SD_DAT2: J3.1 (DAT2), R42.2, U1.51 (SDIO_D2)
SD_DAT3: J3.2 (DAT3/CD), R40.2, U1.52 (SDIO_D3)
SENSOR_FL: Q6.2 (E), R9.1, U1.16 (ADC1_IN2)
SENSOR_FR: Q8.2 (E), R12.1, U1.14 (ADC1_IN0)
SENSOR_L: Q2.2 (E), R1.1, U1.17 (ADC1_IN3)
SENSOR_R: Q4.2 (E), R6.1, U1.15 (ADC1_IN1)
SWCLK: J1.3, U1.49 (SYS_JTCK-SWCLK)
SWDIO: J1.5, U1.46 (SYS_JTMS-SWDIO)
UART_RX: J1.8, U1.43 (USART1_RX)
UART_TX: J1.6, U1.42 (USART1_TX)
VBAT: C2.1, C8.1, C11.1, C12.1, C26.1, D13.1 (K), FAN1.1 (+), Q9.3 (D), R14.2, U2.3 (VI), U5.13 (VM2), U5.14 (VM3), U5.24 (VM1)
VOL_CHECK: C27.2, R14.1, R15.2, U1.8 (ADC1_IN10)

Notes on the sheet:
2が+
1が-

Board: 2 copper layers, 87.3 x 100.0 mm, 138 parts (6 on the bottom side), 114 nets.

## Commit log

2026-04-03 Initial commit before KiCad 10 update
2026-05-11 発注用のもの(だと信じたい)ver
